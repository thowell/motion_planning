Commit message: dpo planar quadrotor

File: src/models/biped/urdf/biped_float.urdf (robot description, URDF)
Before this commit: robot flip_5link, 8 links, 7 joints
Links:
- link base: mass 5.354 -> 1.46
